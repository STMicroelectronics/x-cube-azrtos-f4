# IAR project IAP_binary_template.ewp, settings and files
configuration IAP_binary_template (ARM, debug)
  General.OGChipSelectEditMenu: STM32F469NI ST STM32F469NI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../../../../../../Drivers/CMSIS/Include; ../../../../../../../Drivers/BSP/STM32469I-Discovery
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_FW_UPGRADE.BIN
  ILINK.IlinkOutputFile: IAP_binary_template.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f469xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32469I-Discovery
    ../../../../../../../Drivers/BSP/STM32469I-Discovery/: stm32469i_discovery.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
